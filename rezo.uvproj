# Keil uVision project rezo.uvproj, settings and files
target simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rezo
  c flags: Optim=1
  c define: _LCD_DEBUG_ STM32F10X_MD
  c include: C:\Keil\stm32lib\stm32f10x\peripherals\inc;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-rvds.s
    C:/Keil/stm32lib/stm32f10x/peripherals/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c
  group drivers
    ./drivers/: uart.c clock.c configuration.c LCD_4bit.c mac.c
    ./: Retarget.c
  group services
    ./: wireless.c wireless.h
  group application
    ./: main.c
target reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: rezo
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: C:\Keil\stm32lib\stm32f10x\peripherals\inc;.\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
